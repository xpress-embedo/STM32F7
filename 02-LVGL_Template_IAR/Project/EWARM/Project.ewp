# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32F769NI ST STM32F769NI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F769xx; LV_CONF_INCLUDE_SIMPLE
  ICCARM.CCDiagSuppress: Pa082, Pa089, Pa084, Pe188, Pe236, Pe546, Pe111
  ICCARM.CCIncludePath2: ../Core/Inc; C:/Users/xpress_embedo/STM32Cube/Repository/STM32Cube_FW_F7_V1.17.0/Drivers/STM32F7xx_HAL_Driver/Inc; C:/Users/xpress_embedo/STM32Cube/Repository/STM32Cube_FW_F7_V1.17.0/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; C:/Users/xpress_embedo/STM32Cube/Repository/STM32Cube_FW_F7_V1.17.0/Drivers/CMSIS/Device/ST/STM32F7xx/Include; C:/Users/xpress_embedo/STM32Cube/Repository/STM32Cube_FW_F7_V1.17.0/Drivers/CMSIS/Include; ..; ..\..\..\BSP; ..\..\..\BSP\Components; ..\..\..\BSP\Components\adv7533; ..\..\..\BSP\Components\Common; ..\..\..\BSP\Components\ft6x06; ..\..\..\BSP\Components\mx25l512; ..\..\..\BSP\Components\otm8009a; ..\..\..\BSP\Components\wm8994; ..\..\..\BSP\STM32F769i_Discovery; ..\..\..; ..\..\..\ThirdParty
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f769xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f769xx.s
  group Application/User/Core
    ../Core/Src/: main.c rgb_mixer.c stm32f7xx_hal_msp.c stm32f7xx_it.c
  group BSP/Components/adv7533
    ../../../BSP/Components/adv7533/: adv7533.c adv7533.h
  group BSP/Components/Common
    ../../../BSP/Components/Common/: accelero.h audio.h camera.h epd.h gyro.h idd.h io.h lcd.h magneto.h ts.h tsensor.h
  group BSP/Components/ft6x06
    ../../../BSP/Components/ft6x06/: ft6x06.c ft6x06.h
  group BSP/Components/mx251512
    ../../../BSP/Components/mx25l512/: mx25l512.h
  group BSP/Components/otm8009a
    ../../../BSP/Components/otm8009a/: otm8009a.c otm8009a.h
  group BSP/Components/wm8994
    ../../../BSP/Components/wm8994/: wm8994.c wm8994.h
  group BSP/STM32F769i_Discovery
    ../../../BSP/STM32F769i_Discovery/: stm32f769i_discovery.c stm32f769i_discovery.h stm32f769i_discovery_audio.c stm32f769i_discovery_audio.h stm32f769i_discovery_eeprom.c stm32f769i_discovery_eeprom.h stm32f769i_discovery_lcd.c stm32f769i_discovery_lcd.h stm32f769i_discovery_qspi.c stm32f769i_discovery_qspi.h stm32f769i_discovery_sd.c stm32f769i_discovery_sd.h stm32f769i_discovery_sdram.c stm32f769i_discovery_sdram.h stm32f769i_discovery_ts.c stm32f769i_discovery_ts.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    C:/Users/xpress_embedo/STM32Cube/Repository/STM32Cube_FW_F7_V1.17.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c
  group hal_stm_lvgl/tft
    ../../../hal_stm_lvgl/tft/: tft.c tft.h
  group hal_stm_lvgl/touchpad
    ../../../hal_stm_lvgl/touchpad/: touchpad.c touchpad.h
  group lvgl
    ../../../ThirdParty/lvgl/: lv_conf_template.h lvgl.h
  group lvgl/demos/benchmark
    ../../../ThirdParty/lvgl/demos/benchmark/: lv_demo_benchmark.c lv_demo_benchmark.h
  group lvgl/demos/benchmark/assets
    ../../../ThirdParty/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group lvgl/examples
    ../../../ThirdParty/lvgl/examples/: lv_examples.h
  group lvgl/examples/get_started
    ../../../ThirdParty/lvgl/examples/get_started/: lv_example_get_started.h lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c
  group lvgl/src
    ../../../ThirdParty/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group lvgl/src/core
    ../../../ThirdParty/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group lvgl/src/draw
    ../../../ThirdParty/lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_layer.c lv_draw_layer.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_transform.c lv_draw_transform.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group lvgl/src/draw/arm2d
    ../../../ThirdParty/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c lv_gpu_arm2d.h
  group lvgl/src/draw/gd32_ipa
    ../../../ThirdParty/lvgl/src/draw/gd32_ipa/: lv_gpu_gd32_ipa.c lv_gpu_gd32_ipa.h
  group lvgl/src/draw/sdl
    ../../../ThirdParty/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_layer.h lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
  group lvgl/src/draw/stm32_dma2d
    ../../../ThirdParty/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group lvgl/src/draw/sw
    ../../../ThirdParty/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl/src/draw/swm341_dma2d
    ../../../ThirdParty/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c lv_gpu_swm341_dma2d.h
  group lvgl/src/font
    ../../../ThirdParty/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group lvgl/src/hal
    ../../../ThirdParty/lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/src/layouts/flex
    ../../../ThirdParty/lvgl/src/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/src/layouts/grid
    ../../../ThirdParty/lvgl/src/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/src/libs/bmp
    ../../../ThirdParty/lvgl/src/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/src/libs/ffmpeg
    ../../../ThirdParty/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
  group lvgl/src/libs/freetype
    ../../../ThirdParty/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype.h
  group lvgl/src/libs/fsdrv
    ../../../ThirdParty/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
  group lvgl/src/libs/gif
    ../../../ThirdParty/lvgl/src/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
  group lvgl/src/libs/png
    ../../../ThirdParty/lvgl/src/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
  group lvgl/src/libs/qrcode
    ../../../ThirdParty/lvgl/src/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
  group lvgl/src/libs/rlottie
    ../../../ThirdParty/lvgl/src/libs/rlottie/: lv_rlottie.c lv_rlottie.h
  group lvgl/src/libs/sjpg
    ../../../ThirdParty/lvgl/src/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
  group lvgl/src/libs/tiny_ttf
    ../../../ThirdParty/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c lv_tiny_ttf.h stb_rect_pack.h stb_truetype_htcw.h
  group lvgl/src/misc
    ../../../ThirdParty/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_malloc_builtin.c lv_malloc_builtin.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_memcpy_builtin.c lv_memcpy_builtin.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group lvgl/src/others/file_explorer
    ../../../ThirdParty/lvgl/src/others/file_explorer/: lv_file_explorer.c lv_file_explorer.h
  group lvgl/src/others/fragment
    ../../../ThirdParty/lvgl/src/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c
  group lvgl/src/others/gridnav
    ../../../ThirdParty/lvgl/src/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/src/others/ime
    ../../../ThirdParty/lvgl/src/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h
  group lvgl/src/others/imgfont
    ../../../ThirdParty/lvgl/src/others/imgfont/: lv_imgfont.c lv_imgfont.h
  group lvgl/src/others/monkey
    ../../../ThirdParty/lvgl/src/others/monkey/: lv_monkey.c lv_monkey.h
  group lvgl/src/others/msg
    ../../../ThirdParty/lvgl/src/others/msg/: lv_msg.c lv_msg.h
  group lvgl/src/others/snapshot
    ../../../ThirdParty/lvgl/src/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/src/themes
    ../../../ThirdParty/lvgl/src/themes/: lv_themes.h
  group lvgl/src/themes/basic
    ../../../ThirdParty/lvgl/src/themes/basic/: lv_theme_basic.c lv_theme_basic.h
  group lvgl/src/themes/default
    ../../../ThirdParty/lvgl/src/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/src/themes/mono
    ../../../ThirdParty/lvgl/src/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/src/widgets/animing
    ../../../ThirdParty/lvgl/src/widgets/animimg/: lv_animimg.c lv_animimg.h
  group lvgl/src/widgets/arc
    ../../../ThirdParty/lvgl/src/widgets/arc/: lv_arc.c lv_arc.h
  group lvgl/src/widgets/bar
    ../../../ThirdParty/lvgl/src/widgets/bar/: lv_bar.c lv_bar.h
  group lvgl/src/widgets/btn
    ../../../ThirdParty/lvgl/src/widgets/btn/: lv_btn.c lv_btn.h
  group lvgl/src/widgets/btnmatrix
    ../../../ThirdParty/lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c lv_btnmatrix.h
  group lvgl/src/widgets/calendar
    ../../../ThirdParty/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
  group lvgl/src/widgets/canvas
    ../../../ThirdParty/lvgl/src/widgets/canvas/: lv_canvas.c lv_canvas.h
  group lvgl/src/widgets/chart
    ../../../ThirdParty/lvgl/src/widgets/chart/: lv_chart.c lv_chart.h
  group lvgl/src/widgets/checkbox
    ../../../ThirdParty/lvgl/src/widgets/checkbox/: lv_checkbox.c lv_checkbox.h
  group lvgl/src/widgets/colorwheel
    ../../../ThirdParty/lvgl/src/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
  group lvgl/src/widgets/dropdown
    ../../../ThirdParty/lvgl/src/widgets/dropdown/: lv_dropdown.c lv_dropdown.h
  group lvgl/src/widgets/img
    ../../../ThirdParty/lvgl/src/widgets/img/: lv_img.c lv_img.h
  group lvgl/src/widgets/imgbtn
    ../../../ThirdParty/lvgl/src/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
  group lvgl/src/widgets/keyboard
    ../../../ThirdParty/lvgl/src/widgets/keyboard/: lv_keyboard.c lv_keyboard.h
  group lvgl/src/widgets/label
    ../../../ThirdParty/lvgl/src/widgets/label/: lv_label.c lv_label.h
  group lvgl/src/widgets/led
    ../../../ThirdParty/lvgl/src/widgets/led/: lv_led.c lv_led.h
  group lvgl/src/widgets/line
    ../../../ThirdParty/lvgl/src/widgets/line/: lv_line.c lv_line.h
  group lvgl/src/widgets/list
    ../../../ThirdParty/lvgl/src/widgets/list/: lv_list.c lv_list.h
  group lvgl/src/widgets/menu
    ../../../ThirdParty/lvgl/src/widgets/menu/: lv_menu.c lv_menu.h
  group lvgl/src/widgets/meter
    ../../../ThirdParty/lvgl/src/widgets/meter/: lv_meter.c lv_meter.h
  group lvgl/src/widgets/msgbox
    ../../../ThirdParty/lvgl/src/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
  group lvgl/src/widgets/objx_templ
    ../../../ThirdParty/lvgl/src/widgets/objx_templ/: lv_objx_templ.c lv_objx_templ.h
  group lvgl/src/widgets/roller
    ../../../ThirdParty/lvgl/src/widgets/roller/: lv_roller.c lv_roller.h
  group lvgl/src/widgets/slider
    ../../../ThirdParty/lvgl/src/widgets/slider/: lv_slider.c lv_slider.h
  group lvgl/src/widgets/span
    ../../../ThirdParty/lvgl/src/widgets/span/: lv_span.c lv_span.h
  group lvgl/src/widgets/spinbox
    ../../../ThirdParty/lvgl/src/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
  group lvgl/src/widgets/spinner
    ../../../ThirdParty/lvgl/src/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/src/widgets/switch
    ../../../ThirdParty/lvgl/src/widgets/switch/: lv_switch.c lv_switch.h
  group lvgl/src/widgets/table
    ../../../ThirdParty/lvgl/src/widgets/table/: lv_table.c lv_table.h
  group lvgl/src/widgets/tabview
    ../../../ThirdParty/lvgl/src/widgets/tabview/: lv_tabview.c lv_tabview.h
  group lvgl/src/widgets/textarea
    ../../../ThirdParty/lvgl/src/widgets/textarea/: lv_textarea.c lv_textarea.h
  group lvgl/src/widgets/titleview
    ../../../ThirdParty/lvgl/src/widgets/tileview/: lv_tileview.c lv_tileview.h
  group lvgl/src/widgets/win
    ../../../ThirdParty/lvgl/src/widgets/win/: lv_win.c lv_win.h
  group Utilities/Fonts
    ../../../Utilities/Fonts/: font12.c font16.c font20.c font24.c font8.c fonts.h
